# Keil uVision project 51car.uvproj, settings and files
target 51car (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0x0-0xFF) XRAM(0x0-0xFFFF) CLOCK(11059200) CPUTYPE("8052")
  output: 51car +hex
  c flags: Optim=8 wLevel=2
  c include: ..\config;..\include;..\common;..\main;..\app;..\drivers\motor;..\drivers\tracking;..\drivers\ultrasonic;..\drivers\servo;..\drivers\remote;..\drivers\display;..\drivers\keys;..\drivers\buzzer_led
  group main
    ../main/: main.c
  group app
    ../app/: app.c pid.c
  group drivers\motor
    ../drivers/motor/: motor.c encoder.c
  group drivers\tracking
    ../drivers/tracking/: tracking.c
  group common
    ../common/: delay.c tick.c
